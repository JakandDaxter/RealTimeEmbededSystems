# Keil uVision project Servo_Controller_RTOS.uvprojx, settings and files
target Servo_Controller_RTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Servo_Controller_RTOS +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx
  c include: ../../../../../../../Inc;../../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/CDC/Inc;../../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../../Drivers/CMSIS/Include
  asm include: ..\..\..\..\..\..\..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Application/User
    ../../../../../../../Src/: main.c freertos.c usb_host.c usbh_conf.c usbh_platform.c stm32l4xx_it.c stm32l4xx_hal_msp.c stm32l4xx_hal_timebase_tim.c
    ./: servo.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_hcd.c stm32l4xx_ll_usb.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_lcd.c stm32l4xx_hal_qspi.c stm32l4xx_hal_sai.c stm32l4xx_hal_sai_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c
  group Drivers/CMSIS
    ../../../../../../../Src/: system_stm32l4xx.c
  group Middlewares/FreeRTOS
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Host_Library
    ../../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/CDC/Src/: usbh_cdc.c
software components: CMSIS:CORE 4.3.0
