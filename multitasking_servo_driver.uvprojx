# Keil uVision project multitasking_servo_driver.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476JGYx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: multitasking_servo_driver +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Source Group 1
    ./: LED.c LED.h main.c startup_stm32l476xx.s SysClock.c SysClock.h UART.c UART.h Timer_3_PIT.c Timer_3_PIT.h Stack.c Servo_CL_Compiler.c Servo_CL_Compiler.h States.h Stack.h Timer_5_PIT.c Timer_5_PIT.h
software components: CMSIS:CORE 5.1.2
